v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 2410 -670 2410 -650 {
lab=in}
N 2410 -760 2410 -730 {
lab=out}
C {sky130_fd_pr/res_generic_m1.sym} 2410 -700 0 0 {name=R1
W=10
L=10
model=res_generic_m1
mult=1}
C {devices/ipin.sym} 2410 -650 3 0 {name=p1 lab=in}
C {devices/opin.sym} 2410 -760 3 0 {name=p2 lab=out}
