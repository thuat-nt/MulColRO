v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {ColROs.sym} 10 -30 0 0 {name=xMulColROs[3:0]}
C {devices/ipin.sym} -400 0 0 0 {name=p2 lab=REG1}
C {devices/ipin.sym} -400 40 0 0 {name=p3 lab=REG2}
C {devices/ipin.sym} -400 80 0 0 {name=p4 lab=REG3}
C {devices/ipin.sym} -400 -40 0 0 {name=p5 lab=REG0}
C {devices/ipin.sym} -400 160 0 0 {name=p8 lab=REG5}
C {devices/ipin.sym} -400 200 0 0 {name=p9 lab=REG6}
C {devices/ipin.sym} -400 120 0 0 {name=p6 lab=REG4}
C {devices/ipin.sym} -400 -380 0 0 {name=p11 lab=AIn0}
C {devices/ipin.sym} -400 -340 0 0 {name=p12 lab=AIn[3:0]}
C {devices/ipin.sym} -400 -300 0 0 {name=p13 lab=AIn2}
C {devices/ipin.sym} -400 -260 0 0 {name=p14 lab=AIn3}
C {devices/ipin.sym} -400 -220 0 0 {name=p15 lab=AIn4}
C {devices/ipin.sym} -400 -180 0 0 {name=p16 lab=AIn5}
C {devices/lab_pin.sym} -400 -380 2 0 {name=p17 sig_type=std_logic lab=AIn0}
C {devices/lab_pin.sym} -400 -340 2 0 {name=p24 sig_type=std_logic lab=AIn[3:0]}
C {devices/lab_pin.sym} -400 -300 2 0 {name=p25 sig_type=std_logic lab=AIn2}
C {devices/lab_pin.sym} -400 -260 2 0 {name=p26 sig_type=std_logic lab=AIn3}
C {devices/lab_pin.sym} -400 -220 2 0 {name=p27 sig_type=std_logic lab=AIn4}
C {devices/lab_pin.sym} -400 -180 2 0 {name=p28 sig_type=std_logic lab=AIn5}
C {devices/lab_pin.sym} -400 -40 2 0 {name=p29 sig_type=std_logic lab=REG0}
C {devices/lab_pin.sym} -400 0 2 0 {name=p30 sig_type=std_logic lab=REG1}
C {devices/lab_pin.sym} -400 40 2 0 {name=p31 sig_type=std_logic lab=REG2}
C {devices/lab_pin.sym} -400 80 2 0 {name=p32 sig_type=std_logic lab=REG3}
C {devices/lab_pin.sym} -400 120 2 0 {name=p33 sig_type=std_logic lab=REG4}
C {devices/lab_pin.sym} -400 160 2 0 {name=p34 sig_type=std_logic lab=REG5}
C {devices/lab_pin.sym} -400 200 2 0 {name=p35 sig_type=std_logic lab=REG6}
C {devices/iopin.sym} -390 -460 2 0 {name=p10 lab=GROUND}
C {devices/lab_pin.sym} -390 -460 2 0 {name=p54 sig_type=std_logic lab=GROUND}
C {devices/iopin.sym} -390 -510 2 0 {name=p55 lab=VDD}
C {devices/lab_pin.sym} -390 -510 2 0 {name=p56 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -140 -30 0 0 {name=p1 sig_type=std_logic lab=REG0}
C {devices/lab_pin.sym} -140 -10 0 0 {name=p7 sig_type=std_logic lab=REG1}
C {devices/lab_pin.sym} -140 10 0 0 {name=p18 sig_type=std_logic lab=REG2}
C {devices/lab_pin.sym} -140 30 0 0 {name=p19 sig_type=std_logic lab=REG3}
C {devices/lab_pin.sym} -140 50 0 0 {name=p20 sig_type=std_logic lab=REG4}
C {devices/lab_pin.sym} -140 70 0 0 {name=p21 sig_type=std_logic lab=REG5}
C {devices/lab_pin.sym} -140 90 0 0 {name=p22 sig_type=std_logic lab=REG6}
C {devices/lab_pin.sym} -140 -150 0 0 {name=p23 sig_type=std_logic lab=AIn0}
C {devices/lab_pin.sym} -140 -130 0 0 {name=p36 sig_type=std_logic lab=AIn[3:0]}
C {devices/lab_pin.sym} 10 -200 1 0 {name=p37 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 10 140 3 0 {name=p38 sig_type=std_logic lab=GROUND}
C {devices/lab_pin.sym} -140 -50 0 0 {name=p39 sig_type=std_logic lab=AIn5}
C {devices/lab_pin.sym} -140 -70 0 0 {name=p40 sig_type=std_logic lab=AIn4}
C {devices/lab_pin.sym} -140 -90 0 0 {name=p41 sig_type=std_logic lab=AIn3}
C {devices/lab_pin.sym} -140 -110 0 0 {name=p42 sig_type=std_logic lab=AIn2}
C {devices/opin.sym} 310 -170 0 0 {name=p43 lab=AOut[3:0]}
C {devices/lab_pin.sym} 310 -170 0 0 {name=p44 sig_type=std_logic lab=AOut[3:0]}
C {devices/lab_pin.sym} 160 -170 3 0 {name=p45 sig_type=std_logic lab=AOut[3:0]}
